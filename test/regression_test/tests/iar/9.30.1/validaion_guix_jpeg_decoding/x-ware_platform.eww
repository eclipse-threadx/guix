<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\demo_guix_jpeg_decode_1555xrgb\demo_guix_jpeg_decode_1555xrgb.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\demo_guix_jpeg_decode_24xrgb\demo_guix_jpeg_decode_24xrgb.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\demo_guix_jpeg_decode_24xrgb_rotated_ccw\demo_guix_jpeg_decode_24xrgb_rotated_ccw.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\demo_guix_jpeg_decode_24xrgb_rotated_cw\demo_guix_jpeg_decode_24xrgb_rotated_cw.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\demo_guix_jpeg_decode_565rgb\demo_guix_jpeg_decode_565rgb.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\demo_guix_jpeg_decode_565rgb_rotated_ccw\demo_guix_jpeg_decode_565rgb_rotated_ccw.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\demo_guix_jpeg_decode_565rgb_rotated_cw\demo_guix_jpeg_decode_565rgb_rotated_cw.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\demo_guix_jpeg_decode_8bit_palette\demo_guix_jpeg_decode_8bit_palette.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\gx\gx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tx\tx.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>build_all</name>
            <member>
                <project>tx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>gx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>gx</project>
                <configuration>Debug_Helium</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_1555xrgb</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_1555xrgb</project>
                <configuration>Debug_Helium</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_24xrgb</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_24xrgb</project>
                <configuration>Debug_Helium</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_24xrgb_rotated_ccw</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_24xrgb_rotated_ccw</project>
                <configuration>Debug_Helium</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_24xrgb_rotated_cw</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_24xrgb_rotated_cw</project>
                <configuration>Debug_Helium</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_565rgb</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_565rgb</project>
                <configuration>Debug_Helium</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_565rgb_rotated_ccw</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_565rgb_rotated_ccw</project>
                <configuration>Debug_Helium</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_565rgb_rotated_cw</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_565rgb_rotated_cw</project>
                <configuration>Debug_Helium</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_8bit_palette</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>demo_guix_jpeg_decode_8bit_palette</project>
                <configuration>Debug_Helium</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
