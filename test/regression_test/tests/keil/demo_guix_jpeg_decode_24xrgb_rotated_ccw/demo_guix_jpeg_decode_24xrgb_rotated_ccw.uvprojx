# Keil uVision project demo_guix_jpeg_decode_24xrgb_rotated_ccw.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: SSE-310-MPS3_FVP ARM
  pack: ARM.V2M_MPS3_SSE_310_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00008000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00002000) XRAM2(0x20002000,0x00002000) XRAM3(0x20004000,0x00002000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: demo_guix_jpeg_decoding_565rgb
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: TX_SINGLE_MODE_NON_SECURE
  c include: ..\..\..\..\..\common\inc;..\..\..\..\..\ports\generic\inc;..\..\..\..\..\externals\threadx\common\inc;..\..\..\..\..\externals\threadx\ports\cortex_m85\ac6\inc;..\
  asm define: TX_SINGLE_MODE_NON_SECURE
  memory RVCT6: RAM 0x20000000 size 0x2000
  memory RVCT7: RAM 0x20002000 size 0x2000
  memory RVCT8: RAM 0x20004000 size 0x2000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: ..\test.sct
  group Src
    ./: main.c demo_jpeg_decode_24xrgb_rotated_ccw_resources.c demo_jpeg_decode_24xrgb_rotated_ccw_specifications.c demo_jpeg_decode_24xrgb_rotated_ccw_resources.h demo_jpeg_decode_24xrgb_rotated_ccw_specifications.h
    ../: common_code.c common_code.h stdout_USART.c
  group libs
    C:/Ting/guix/test/regression_test/tests/keil/gx/Objects/: gx.lib
    C:/Ting/guix/test/regression_test/tests/keil/tx/Objects/: tx.lib
software components: CMSIS Driver:USART 1.1.0, CMSIS:CORE 5.6.0, Device:Definition 1.2.0, Device:Startup 1.2.0, Native Driver:IO 1.0.1, Native Driver:SysCounter 1.0.1, Native Driver:SysTimer 1.0.0, Native Driver:Timeout 1.0.1, Native Driver:UART 1.1.0, Native Driver:Watchdog 1.0.1, Compiler:I/O:STDOUT 1.2.0
