# IAR project demo_guix_jpeg_decode_565rgb_rotated_cw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\externals\threadx\common\inc; ..\..\..\..\..\..\..\externals\threadx\ports\cortex_m85\iar\inc; ..\..\..\..\..\..\..\common\inc; ..\..\..\..\..\..\..\\ports\cortex_m7\iar\inc; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo_guix_jpeg_decode_565rgb_rotated_cw.hex
  ILINK.IlinkOutputFile: demo_guix_jpeg_decode_565rgb_rotated_cw.out
  ILINK.IlinkIcfFile: ..\test_flash.icf
  ILINK.IlinkAdditionalLibs: ..\gx\Debug\Exe\gx.a; ..\tx\Debug\Exe\tx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
configuration Debug_Helium (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkAdditionalLibs: ..\gx\Debug_Helium\Exe\gx.a; ..\tx\Debug\Exe\tx.a
  group (top)
    ../: common_code.c common_code.h
    ./: demo_jpeg_decode_565rgb_rotated_cw_resources.c demo_jpeg_decode_565rgb_rotated_cw_resources.h demo_jpeg_decode_565rgb_rotated_cw_specifications.c demo_jpeg_decode_565rgb_rotated_cw_specifications.h main.c
