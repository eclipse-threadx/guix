# IAR project demo_guix_jpeg_decode_24xrgb_rotated_ccw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\externals\threadx\common\inc; ..\..\..\..\..\..\..\externals\threadx\ports\cortex_m85\iar\inc; ..\..\..\..\..\..\..\common\inc; ..\..\..\..\..\..\..\\ports\cortex_m7\iar\inc; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo_guix_jpeg_decode_24xrgb_rotated_ccw.hex
  ILINK.IlinkOutputFile: demo_guix_jpeg_decode_24xrgb_rotated_ccw.out
  ILINK.IlinkIcfFile: ..\test_flash.icf
  ILINK.IlinkAdditionalLibs: ..\gx\Debug\Exe\gx.a; ..\tx\Debug\Exe\tx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
configuration Debug_Helium (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 64
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\gx\Debug_Helium\Exe\gx.a; ..\tx\Debug\Exe\tx.a
  group (top)
    ../: common_code.c common_code.h
    ./: demo_jpeg_decode_24xrgb_rotated_ccw_resources.c demo_jpeg_decode_24xrgb_rotated_ccw_resources.h demo_jpeg_decode_24xrgb_rotated_ccw_specifications.c demo_jpeg_decode_24xrgb_rotated_ccw_specifications.h main.c
