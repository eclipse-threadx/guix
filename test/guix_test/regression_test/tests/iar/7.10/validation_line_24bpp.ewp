# IAR project validation_line_24bpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: GX_VALIDATION_NO_OUTPUT_FILE
  ICCARM.CCIncludePath2: ..\..\..\..\..\examples\lines; ..\..\..\..\..\port_files\linux_validation; ..\..\..\..\..\externals\binary\ThreadX\Cortex-M4; ..\..\..\..\..\src\trunk; ..\..\..\utility; ..\..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: validation_line_24bpp.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\port_files\cortex-m4\iar\demo_guix.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../externals/binary/ThreadX/Cortex-M4/: cstartup_M.s tx.a tx_initialize_low_level.s
    ../../../../../src/trunk/build/cortex-m4/iar/7.10/Debug/Exe/: gx.a
    ../../../utility/: gx_validation_display_driver_16bpp.c gx_validation_display_driver_24bpp.c gx_validation_utility.c gx_validation_verify.c
    ../../../../../examples/lines/: lines_resources.c lines_specifications.c
    ../../: validation_guix_lines_24xrgb.c
